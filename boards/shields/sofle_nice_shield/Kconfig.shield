## boards/shields/sofle_nice_shield/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SHIELD_BASE
    def_bool $(shields_list_contains,sofle_nice_shield)
```
